# IAR project mathlib.ewp, settings and files
configuration q32m210 (ARM, debug)
  General.OGChipSelectEditMenu: Q32M210 ON Semiconductor Q32M210
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: Q32_CID=0x050101
  ICCARM.CCIncludePath2: ..\..\..\Include; ..\..\..\..\..\..\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $TOOLKIT_DIR$\inc\ONSemiconductor
  OBJCOPY.OOCOutputFile: mathlib.srec
  ILINK.IlinkOutputFile: mathlib.out
  group (top)
    ../: q32_math_version.c
  group Source
    ../: q32_math_float.c q32_math_frac32.c
