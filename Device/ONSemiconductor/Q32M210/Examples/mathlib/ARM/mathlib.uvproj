# Keil uVision project mathlib.uvproj, settings and files
target mathlib (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: mathlib (library)
  c flags: Optim=1
  c define: Q32_CID=0x050101
  c include: ..\..\..\Include;..\..\..\..\..\..\CMSIS\Include
  memory RVCT4: ROM 0x40000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source
    ../: q32_math_float.c q32_math_frac32.c q32_math_version.c
