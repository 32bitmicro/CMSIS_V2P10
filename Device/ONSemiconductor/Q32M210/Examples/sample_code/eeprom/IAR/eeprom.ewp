# IAR project eeprom.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Q32M210 ON Semiconductor Q32M210
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: Q32_CID=0x050101
  ICCARM.CCIncludePath2: ..\..\..\..\Include; ..\..\..\..\..\..\..\CMSIS\Include; ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $TOOLKIT_DIR$\inc\ONSemiconductor
  OBJCOPY.OOCOutputFile: eeprom.hex
  ILINK.IlinkOutputFile: eeprom.out
  ILINK.IlinkIcfFile: ..\..\..\..\Source\Templates\IAR\q32m210.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Source/Templates/IAR/: startup_q32m210.s
    ../../../../Source/Templates/: system_Q32M210.c
  group Include
    ../: globals.h
  group Libraries
    ../../../syslib/IAR/q32m210/Exe/: q32m210_syslib.a
    ../../../eepromlib/IAR/q32m210/Exe/: q32m210_eepromlib.a
  group Source
    ../../common/: initialize.c
    ../: interrupts.c main.c
