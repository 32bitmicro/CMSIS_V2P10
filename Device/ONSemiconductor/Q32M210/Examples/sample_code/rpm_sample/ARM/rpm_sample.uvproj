# Keil uVision project rpm_sample.uvproj, settings and files
target rpm_sample (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: rpm_sample +hex
  c flags: Optim=1
  c define: Q32_CID=0x050101
  c include: ..\..\..\..\Include;..\..\..\..\..\..\..\CMSIS\Include;..
  library: MicroLIB
  memory RVCT4: ROM 0x40000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../../../../Source/Templates/ARM/: startup_Q32M210.s
    ../../../../Source/Templates/: system_Q32M210.c
  group Include
    ../: globals.h adc.h rtc.h usb.h version.h
  group Source
    ../../common/: initialize.c
    ../: interrupts.c main.c adc.c rtc.c usb.c
  group Libraries
    ../../../syslib/ARM/: syslib.lib
