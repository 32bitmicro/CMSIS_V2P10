# Keil uVision project pcm.uvproj, settings and files
target pcm_master (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: pcm +hex
  c flags: Optim=1
  c define: Q32_CID=0x050101,PCM_MASTER
  c include: ..\..\..\..\Include;..\..\..\..\..\..\..\CMSIS\Include;..
  library: MicroLIB
  memory RVCT4: ROM 0x40000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../../../../Source/Templates/ARM/: startup_Q32M210.s
    ../../../../Source/Templates/: system_Q32M210.c
  group Include
    ../: globals.h
  group Source
    ../../common/: initialize.c
    ../: interrupts.c main.c
  group Libraries
    ../../../syslib/ARM/: syslib.lib
target pcm_slave (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: pcm +hex
  c flags: Optim=1
  c define: Q32_CID=0x050101,PCM_SLAVE
  c include: ..\..\..\..\Include;..\..\..\..\..\..\..\CMSIS\Include;..
  library: MicroLIB
  memory RVCT4: ROM 0x40000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
