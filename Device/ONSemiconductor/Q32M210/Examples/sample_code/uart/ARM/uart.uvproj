# Keil uVision project uart.uvproj, settings and files
target uart_to_pc (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: uart +hex
  c flags: Optim=1
  c define: Q32_CID=0x050101,UART_TO_PC=1,UART_LOOPBACK=0,BUILD_TYPE=UART_TO_PC
  c include: ..\..\..\..\Include;..\..\..\..\..\..\..\CMSIS\Include;..
  library: MicroLIB
  memory RVCT4: ROM 0x40000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../../../../Source/Templates/ARM/: startup_Q32M210.s
    ../../../../Source/Templates/: system_Q32M210.c
  group Include
    ../: globals.h
  group Source
    ../../common/: initialize.c
    ../: interrupts.c main.c
  group Libraries
    ../../../syslib/ARM/: syslib.lib
target uart_loopback (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: uart +hex
  c flags: Optim=1
  c define: Q32_CID=0x050101,UART_TO_PC=1,UART_LOOPBACK=0,BUILD_TYPE=UART_LOOPBACK
  c include: ..\..\..\..\Include;..\..\..\..\..\..\..\CMSIS\Include;..
  library: MicroLIB
  memory RVCT4: ROM 0x40000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
