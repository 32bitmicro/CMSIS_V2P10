# IAR project uart.ewp, settings and files
configuration UART_TO_PC (ARM, debug)
  General.OGChipSelectEditMenu: Q32M210 ON Semiconductor Q32M210
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: Q32_CID=0x050101; UART_LOOPBACK=0; UART_TO_PC=1; BUILD_TYPE=UART_TO_PC
  ICCARM.CCIncludePath2: ..\..\..\..\Include; ..\..\..\..\..\..\..\CMSIS\Include; ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $TOOLKIT_DIR$\inc\ONSemiconductor
  OBJCOPY.OOCOutputFile: pcm.hex
  ILINK.IlinkOutputFile: pcm.out
  ILINK.IlinkIcfFile: ..\..\..\..\Source\Templates\IAR\q32m210.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration UART_LOOPBACK (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q32_CID=0x050101; UART_LOOPBACK=0; UART_TO_PC=1; BUILD_TYPE=UART_LOOPBACK
  group CMSIS
    ../../../../Source/Templates/IAR/: startup_q32m210.s
    ../../../../Source/Templates/: system_Q32M210.c
  group Include
    ../: globals.h
  group Libraries
    ../../../syslib/IAR/q32m210/Exe/: q32m210_syslib.a
  group Source
    ../../common/: initialize.c
    ../: interrupts.c main.c
