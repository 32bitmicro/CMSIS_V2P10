<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\syslib\IAR\syslib.ewp</path>
  </project>
  <batchBuild/>
</workspace>
