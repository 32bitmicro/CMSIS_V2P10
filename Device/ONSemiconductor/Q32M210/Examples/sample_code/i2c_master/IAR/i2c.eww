<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\i2c_master.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\i2c_slave\IAR\i2c_slave.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\syslib\IAR\syslib.ewp</path>
  </project>
  <batchBuild/>
</workspace>
