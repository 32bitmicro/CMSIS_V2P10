# IAR project eepromlib.ewp, settings and files
configuration q32m210 (ARM, debug)
  General.OGChipSelectEditMenu: Q32M210 ON Semiconductor Q32M210
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: Q32_CID=0x050101
  ICCARM.CCIncludePath2: ..\..\..\Include; ..\..\..\..\..\..\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $TOOLKIT_DIR$\inc\ONSemiconductor
  OBJCOPY.OOCOutputFile: eepromlib.srec
  ILINK.IlinkOutputFile: eepromlib.out
  group (top)
    ../: q32_eeprom_version.c
  group Include
    ../: q32_eeprom_internal.h
  group Source
    ../: q32_eeprom_config.c q32_eeprom_init.c q32_eeprom_transfer.c
