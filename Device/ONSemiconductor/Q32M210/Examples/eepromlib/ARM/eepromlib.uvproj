# Keil uVision project eepromlib.uvproj, settings and files
target eepromlib (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: eepromlib (library)
  c flags: Optim=1
  c define: Q32_CID=0x050101
  c include: ..\..\..\Include;..\..\..\..\..\..\CMSIS\Include
  memory RVCT4: ROM 0x40000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Include
    ../: q32_eeprom_internal.h
  group Source
    ../: q32_eeprom_config.c q32_eeprom_init.c q32_eeprom_transfer.c q32_eeprom_version.c
