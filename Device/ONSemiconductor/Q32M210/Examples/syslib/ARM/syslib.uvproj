# Keil uVision project syslib.uvproj, settings and files
target syslib (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: syslib (library)
  c flags: Optim=1
  c define: Q32_CID=0x050101
  c include: ..\..\..\Include;..\..\..\..\..\..\CMSIS\Include
  memory RVCT4: ROM 0x40000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Analog
    ../: q32_analog_clock.c q32_analog_rtc.c
  group Include
    ../../../Include/: q32.h q32_analog.h q32_clock.h q32_crc.h q32_dma.h q32_eeprom.h q32_flash.h q32_gpio.h q32_i2c.h q32_lcd.h q32_math.h q32_operatingmode.h q32_pcm.h q32_reg.h q32_spi.h q32_sys.h q32_systick.h q32_timers.h q32_uart.h q32_usb.h q32_watchdog.h q32m200_cm3.h q32m200_nvic.h q32m210.h q32m210_romvect.h
  group Interfaces
    ../: q32_lcd.c q32_uart.c q32_usb.c
  group Peripherals
    ../: q32_dma.c q32_timers.c q32m200_nvic.c
  group Support
    ../: q32_version.c q32_operatingmode.c q32m200_cm3.c q32m210_romvect.c
    ./: q32m200_cm3_asm.s q32m200_sys_asm.s
